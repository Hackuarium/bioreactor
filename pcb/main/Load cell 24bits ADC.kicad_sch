File: pcb/main/Load cell 24bits ADC.kicad_sch (KiCad schematic)
At the start: 17 parts, among them J9 SJ, Q4 TRANSISTOR_PNPMMBT4403, U4 HX711

Commit message: Add fields to PCBA
Parts:
- C16, C18, C19, C20: value 100nF -> 100n; MFN (none) -> Samsung Electro-Mechanics; MFP (none) -> CL21A106KOQNNNG; S1PL (none) -> https://www.mouser.com/ProductDetail/Samsung-Electro-Mechan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; S1PN (none) -> 187-CL21A106KOQNNNG
- C17, C21: value 10uF -> 10u; MFN (none) -> Samsung Electro-Mechanics; MFP (none) -> CL21A106KOQNNNG; S1PL (none) -> https://www.mouser.com/ProductDetail/Samsung-Electro-Mechan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; S1PN (none) -> 187-CL21A106KOQNNNG
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "100nF" (id 1) (at 97.155 126.365 0)
+    (property "Value" "100n" (id 1) (at 97.155 126.365 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Description" "Multilayer Ceramic Capacitors MLCC - SMD/SMT 50V .1uF X7R 0805 10%TOL" (id 4) (at 96.52 123.825 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "Samsung Electro-Mechanics " (id 5) (at 96.52 123.825 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "CL21A106KOQNNNG " (id 6) (at 96.52 123.825 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/Samsung-Electro-Mechanics/CL21A106KOQNNNG?qs=hqM3L16%252BxlcMWI7QbqH0LA%3D%3D" (id 7) (at 96.52 123.825 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" " 187-CL21A106KOQNNNG " (id 8) (at 96.52 123.825 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
   )
   (symbol (lib_id "Device:C") (at 104.775 123.825 0) (unit 1)
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "10uF" (id 1) (at 105.41 126.365 0)
+    (property "Value" "10u" (id 1) (at 105.41 126.365 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (id 3) (at 104.775 123.825 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/585/MLCC-1837944.pdf" (id 3) (at 104.775 123.825 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "Samsung Electro-Mechanics " (id 4) (at 104.775 123.825 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "CL21A106KOQNNNG " (id 5) (at 104.775 123.825 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/Samsung-Electro-Mechanics/CL21A106KOQNNNG?qs=hqM3L16%252BxlcMWI7QbqH0LA%3D%3D" (id 6) (at 104.775 123.825 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" " 187-CL21A106KOQNNNG " (id 7) (at 104.775 123.825 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Description" "Multilayer Ceramic Capacitors MLCC - SMD/SMT 16V 10uF XX5R 0805 10%" (id 8) (at 104.775 123.825 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "100nF" (id 1) (at 123.19 85.09 0)
+    (property "Value" "100n" (id 1) (at 123.19 85.09 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Description" "Multilayer Ceramic Capacitors MLCC - SMD/SMT 50V .1uF X7R 0805 10%TOL" (id 4) (at 122.555 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "Samsung Electro-Mechanics " (id 5) (at 122.555 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "CL21A106KOQNNNG " (id 6) (at 122.555 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/Samsung-Electro-Mechanics/CL21A106KOQNNNG?qs=hqM3L16%252BxlcMWI7QbqH0LA%3D%3D" (id 7) (at 122.555 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" " 187-CL21A106KOQNNNG " (id 8) (at 122.555 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
   )
   (symbol (lib_id "Device:C") (at 130.81 82.55 0) (unit 1)
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "10uF" (id 1) (at 131.445 85.09 0)
+    (property "Value" "10u" (id 1) (at 131.445 85.09 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (id 3) (at 130.81 82.55 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/585/MLCC-1837944.pdf" (id 3) (at 130.81 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "Samsung Electro-Mechanics " (id 4) (at 130.81 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "CL21A106KOQNNNG " (id 5) (at 130.81 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/Samsung-Electro-Mechanics/CL21A106KOQNNNG?qs=hqM3L16%252BxlcMWI7QbqH0LA%3D%3D" (id 6) (at 130.81 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" " 187-CL21A106KOQNNNG " (id 7) (at 130.81 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Description" "Multilayer Ceramic Capacitors MLCC - SMD/SMT 16V 10uF XX5R 0805 10%" (id 8) (at 130.81 82.55 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "100nF" (id 1) (at 148.59 106.68 0)
+    (property "Value" "100n" (id 1) (at 148.59 106.68 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Description" "Multilayer Ceramic Capacitors MLCC - SMD/SMT 50V .1uF X7R 0805 10%TOL" (id 4) (at 147.955 104.14 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "Samsung Electro-Mechanics " (id 5) (at 147.955 104.14 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "CL21A106KOQNNNG " (id 6) (at 147.955 104.14 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/Samsung-Electro-Mechanics/CL21A106KOQNNNG?qs=hqM3L16%252BxlcMWI7QbqH0LA%3D%3D" (id 7) (at 147.955 104.14 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" " 187-CL21A106KOQNNNG " (id 8) (at 147.955 104.14 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
   )
   (symbol (lib_id "Device:C") (at 150.495 93.98 90) (unit 1)
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "100nF" (id 1) (at 153.67 97.155 90)
+    (property "Value" "100n" (id 1) (at 153.67 97.155 90)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Description" "Multilayer Ceramic Capacitors MLCC - SMD/SMT 50V .1uF X7R 0805 10%TOL" (id 4) (at 150.495 93.98 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "Samsung Electro-Mechanics " (id 5) (at 150.495 93.98 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "CL21A106KOQNNNG " (id 6) (at 150.495 93.98 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/Samsung-Electro-Mechanics/CL21A106KOQNNNG?qs=hqM3L16%252BxlcMWI7QbqH0LA%3D%3D" (id 7) (at 150.495 93.98 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" " 187-CL21A106KOQNNNG " (id 8) (at 150.495 93.98 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: Update 2: Fields for BOM with PCBA manufacturer
Parts:
- JP5: MFN (none) -> Molex; MFP (none) -> 22-28-4053; S1PL (none) -> https://www.mouser.com/ProductDetail/Molex/22-28-4053?qs=d9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; S1PN (none) -> 538-22-28-4053
- JP6: MFN (none) -> Molex; MFP (none) -> 22-28-4020; S1PL (none) -> https://www.mouser.com/ProductDetail/Molex/22-28-4020?qs=d9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; S1PN (none) -> 538-22-28-4020
- Q4: MFN (none) -> ON Semiconductor; MFP (none) -> MMBT4403WT1G; S1PL (none) -> https://www.mouser.com/ProductDetail/ON-Semiconductor/MMBT4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; S1PN (none) -> 863-MMBT4403WT1G
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Description" "Multilayer Ceramic Capacitors MLCC - SMD/SMT 16V 10uF XX5R 0805 10%" (id 8) (at 104.775 123.825 0)
+    (property "Description" "Multilayer Ceramic Capacitors MLCC - SMD/SMT 16V 10uF X5R 0805 10%" (id 8) (at 104.775 123.825 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Description" "Multilayer Ceramic Capacitors MLCC - SMD/SMT 16V 10uF XX5R 0805 10%" (id 8) (at 130.81 82.55 0)
+    (property "Description" "Multilayer Ceramic Capacitors MLCC - SMD/SMT 16V 10uF X5R 0805 10%" (id 8) (at 130.81 82.55 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (id 3) (at 142.24 69.85 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/308/MMBT4403WT1-D-1811904.pdf" (id 3) (at 142.24 69.85 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Description" "Bipolar Transistors - BJT 600mA 40V PNP" (id 4) (at 142.24 69.85 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "ON Semiconductor " (id 5) (at 142.24 69.85 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "MMBT4403WT1G " (id 6) (at 142.24 69.85 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/ON-Semiconductor/MMBT4403WT1G?qs=HVbQlW5zcXXliRimP8G%2FVA%3D%3D" (id 7) (at 142.24 69.85 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" " 863-MMBT4403WT1G " (id 8) (at 142.24 69.85 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (id 3) (at 95.25 103.505 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/276/0022284020_PCB_HEADERS-228358.pdf" (id 3) (at 95.25 103.505 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "Molex " (id 4) (at 95.25 103.505 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "22-28-4020" (id 5) (at 95.25 103.505 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/Molex/22-28-4020?qs=d9fIA1aNikTifpx8PDmVSA%3D%3D" (id 6) (at 95.25 103.505 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" " 538-22-28-4020 " (id 7) (at 95.25 103.505 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (id 3) (at 95.25 82.55 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/276/0022284053_PCB_HEADERS-228163.pdf" (id 3) (at 95.25 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "Molex " (id 4) (at 95.25 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "22-28-4053" (id 5) (at 95.25 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/Molex/22-28-4053?qs=d9fIA1aNikRgHwv0ZIzelw%3D%3D" (id 6) (at 95.25 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" " 538-22-28-4053 " (id 7) (at 95.25 82.55 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: Update 3 - BOM for PCBA
Parts:
- R29: MFN (none) -> KOA Speer; MFP (none) -> RK73H2ATTD1002F; S1PL (none) -> https://www.mouser.com/ProductDetail/KOA-Speer/RK73H2ATTD10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; S1PN (none) -> 660-RK73H2ATTD1002F
- R30: MFN (none) -> KOA Speer; MFP (none) -> RK73H2ATTD2002F; S1PL (none) -> https://www.mouser.com/ProductDetail/KOA-Speer/RK73H2ATTD20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; S1PN (none) -> 660-RK73H2ATTD2002F
- R31: MFN (none) -> KOA Speer; MFP (none) -> RK73H2ATTD8201F; S1PL (none) -> https://www.mouser.com/ProductDetail/KOA-Speer/RK73H2ATTD82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; S1PN (none) -> 660-RK73H2ATTD8201F
- R32, R33: MFN (none) -> Bourns; MFP (none) -> CMP0805-FX-1000ELF; S1PL (none) -> https://www.mouser.com/ProductDetail/Bourns/CMP0805-FX-1000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; S1PN (none) -> 652-CMP0805-FX-1000L
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (id 3) (at 139.7 81.28 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/219/RK73H-1825326.pdf" (id 3) (at 139.7 81.28 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Description" "Thick Film Resistors - SMD 1/4watts 20Kohms 1%" (id 4) (at 139.7 81.28 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "KOA Speer " (id 5) (at 139.7 81.28 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "RK73H2ATTD2002F" (id 6) (at 139.7 81.28 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/KOA-Speer/RK73H2ATTD2002F?qs=sGAEpiMZZMtlubZbdhIBIMXh9e%2F%2F%2F5dzn%2FVOqHcJlxA%3D" (id 7) (at 139.7 81.28 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" " 660-RK73H2ATTD2002F " (id 8) (at 139.7 81.28 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (id 3) (at 139.7 90.17 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/219/RK73H-1825326.pdf" (id 3) (at 139.7 90.17 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Description" "Thick Film Resistors - SMD 1/4W 8.2K OHM 1% " (id 4) (at 139.7 90.17 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "KOA Speer " (id 5) (at 139.7 90.17 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "RK73H2ATTD8201F" (id 6) (at 139.7 90.17 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/KOA-Speer/RK73H2ATTD8201F?qs=sGAEpiMZZMtlubZbdhIBIIqLs7HsJDS2YP1fNBux264%3D" (id 7) (at 139.7 90.17 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" " 660-RK73H2ATTD8201F " (id 8) (at 139.7 90.17 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (id 3) (at 140.97 100.33 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/54/Bourns_CMP_Datasheet_05.28.20-1854233.pdf" (id 3) (at 140.97 100.33 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Description" "Thick Film Resistors - SMD 100 OHM 1% 1/2W TC100" (id 4) (at 140.97 100.33 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "Bourns " (id 5) (at 140.97 100.33 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "CMP0805-FX-1000ELF" (id 6) (at 140.97 100.33 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/Bourns/CMP0805-FX-1000ELF?qs=sGAEpiMZZMtlubZbdhIBIIPWN1VQSu3wb553eGoanZQ%3D" (id 7) (at 140.97 100.33 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" " 652-CMP0805-FX-1000L " (id 8) (at 140.97 100.33 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (id 3) (at 140.97 107.95 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/54/Bourns_CMP_Datasheet_05.28.20-1854233.pdf" (id 3) (at 140.97 107.95 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Description" "Thick Film Resistors - SMD 100 OHM 1% 1/2W TC100" (id 4) (at 140.97 107.95 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "Bourns " (id 5) (at 140.97 107.95 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "CMP0805-FX-1000ELF" (id 6) (at 140.97 107.95 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/Bourns/CMP0805-FX-1000ELF?qs=sGAEpiMZZMtlubZbdhIBIIPWN1VQSu3wb553eGoanZQ%3D" (id 7) (at 140.97 107.95 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" " 652-CMP0805-FX-1000L " (id 8) (at 140.97 107.95 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (id 3) (at 187.325 72.39 0)
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/219/RK73H-1825326.pdf" (id 3) (at 187.325 72.39 0)
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Description" "Thick Film Resistors - SMD 1/4W 10K OHM 1%" (id 4) (at 187.325 72.39 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "KOA Speer " (id 5) (at 187.325 72.39 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "RK73H2ATTD1002F" (id 6) (at 187.325 72.39 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.mouser.com/ProductDetail/KOA-Speer/RK73H2ATTD1002F?qs=sGAEpiMZZMtlubZbdhIBIADEshVnklemK%252BhrLNEuMe8%3D" (id 7) (at 187.325 72.39 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PN" " 660-RK73H2ATTD1002F " (id 8) (at 187.325 72.39 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: Update 4 - BOM for PCBA. Ready  to check issue #46
Parts:
- U4: MFN (none) -> Avia Semiconductor; MFP (none) -> HX711; S1PL (none) -> https://www.aliexpress.com/item/33012086165.html?spm=a2g0s.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
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (id 3) (at 170.815 88.9 0)
+    (property "Datasheet" "https://cdn.sparkfun.com/datasheets/Sensors/ForceFlex/hx711_english.pdf" (id 3) (at 170.815 88.9 0)
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Description" "24-Bit Analog-to-Digital Converter (ADC) for Weigh Scales" (id 4) (at 170.815 88.9 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFN" "Avia Semiconductor" (id 5) (at 170.815 88.9 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "MFP" "HX711" (id 6) (at 170.815 88.9 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "S1PL" "https://www.aliexpress.com/item/33012086165.html?spm=a2g0s.9042311.0.0.6efd4c4d7S5uUt" (id 7) (at 170.815 88.9 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
