# Repository Hackuarium/bioreactor

File README.md:

# bioreactor

Please refer to the [documentation](https://hackuarium.github.io/bioreactor/) for all useful information.

## Cloning the project

This project uses SUBMODULES.

In order to clone it use:
`git clone --recurse-submodules https://github.com/Hackuarium/bioreactor.git`

## Pull and update submodules

You should run this commande every time you want to pull:
`git pull --recurse-submodules`

## Submodules update only

To update the submodules:
`git submodule update --recursive --remote`

## KiCad design pcb/main/Bertha_main.kicad_pcb

File pcb/Readme.md (part):

# Tips

## Configure permission for USBTinyISP

- Check the ID for USBTinyISP:

´´´
$ lsusb
´´´

´´´
Bus 002 Device 001: ID 1d6b:0003 Linux Foundation 3.0 root hub
Bus 001 Device 005: ID 8087:0a2b Intel Corp.
Bus 001 Device 006: ID 047f:0115 Plantronics, Inc. Voyager Legend
Bus 001 Device 003: ID 046d:c31c Logitech, Inc. Keyboard K120
Bus 001 Device 002: ID 046d:c011 Logitech, Inc. Optical MouseMan
Bus 001 Device 007: ID 1781:0c9f Multiple Vendors USBtiny
Bus 001 Device 001: ID 1d6b:0002 Linux Foundation 2.0 root hub
´´´

Show _Device 007_ permissions:

´´´
$ ls -al /dev/bus/usb/001/007
´´´

´´´
crw-rw---- 1 root root 189, 6 Okt 2 09:45 /dev/bus/usb/001/007
´´´

Change permissions:

´´´
$ sudo chmod 666 /dev/bus/usb/001/007
´´´

Check the new permissions:

´´´
$ ls -al /dev/bus/usb/001/007
´´´

´´´
crw-rw-rw- 1 root root 189, 6 Okt 2 09:45 /dev/bus/usb/001/007
´´´

## Pin Configuration - Bioreactor V 6.0.1

Based on: [ATMEGA32U4 - Arduino Lilypad USB/Leonardo](https://docs.arduino.cc/hacking/hardware/PinMapping32u4)

| µC Pin                                                               | Pin Port | Digital Port | Analog Port | Alternate Functions                           | Arduino Functions | Bioreactor Functions | Description                                                                                                                                                                                                                           |
| -------------------------------------------------------------------- | -------- | ------------ | ----------- | --------------------------------------------- | ----------------- | -------------------- | ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------- |
| 1                                                                    | PE6      | 7            |             | INT6 <br /> /AIN0                             |                   | TEMP_EXT1            | - **Ext. OneWire 1**. <br /> - External Interrupt 6 Input. <br /> - Analog Comparator Positive Input.                                                                                                                                     |
| 2                                                                    | UVcc     |              |             |                                               | UVCC              | UVCC                 | USB Pads Internal Regulator Input supply voltage.                                                                                                                                                                                     |
| 3                                                                    | D-       |              |             |                                               | RD-               | D-                   | USB Full speed / Low Speed Negative Data Upstream Port. Should be connected to the USB D- connector pin with a serial 22 Ohm resistor.                                                                                                |
| 4                                                                    | D+       |              |             |                                               | RD+               | D+                   | USB Full speed / Low Speed Positive Data Upstream Port. Should be connected to the USB D+ connector pin with a serial 22 Ohm resistor.                                                                                                |
| 5                                                                    | UGND     |              |             |                                               | UGND              | GND                  | USB Pads Ground.                                                                                                                                                                                                                      |
| 6                                                                    | UCap     |              |             |                                               | UCAP              | UCAP                 | USB Pads Internal Regulator Output supply voltage. Should be connected to an external capacitor (1μF).                                                                                                                                |
| 7                                                                    | VBus     |              |             |                                               | VUSB              | VUSB                 | USB VBUS monitor input.                                                                                                                                                                                                               |
| 8                                                                    | PB0      |              |             | /SS <br /> PCINT0                             | RXLED             | RXLED                | - **Serial communication Reception LED**. <br /> - SPI Slave Select input. <br /> - Pin Change Interrupt 0.                                                                                                                               |
| 9                                                                    | PB1      |              |             | SCK <br /> PCINT1                             | SCK               | SCK                  | - SPI Bus Serial Clock. <br /> - Pin Change Interrupt 1.                                                                                                                                                                              |
| 10                                                                   | PB2      |              |             | PDI <br /> MOSI <br /> PCINT2                 | MOSI              | MOSI                 | - Programming Data Input. <br /> - SPI Bus Master Output/Slave Input. <br /> - Pin Change Interrupt 2.                                                                                                                                |
| 11                                                                   | PB3      |              |             | PDO <br /> MISO <br /> PCINT3                 | MISO              | MISO                 | - Programming Data Output. <br /> - SPI Bus Master Input/Slave Output. <br /> - Pin Change Interrupt 3.                                                                                                                               |
| 12                                                                   | PB7      | 11           |             | OC0A <br /> OC1C <br /> PCINT7 <br /> /RTS    | PWM               | OUT_FAN              | - **Fan control**. <br /> - Output Compare and PWM Output A for Timer/Counter0. <br /> - Output Compare and PWM Output C for Timer/Counter1. <br /> - Pin Change Interrupt 7. <br /> - UART flow control RTS signal.                      |
| 13                                                                   | /RESET   |              |             |                                               | /RESET            | /RESET               | Reset input.                                                                                                                                                                                                                          |

Parts:
C1, C3, C4: 10u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C5, C6, C7, C11, C34, C35, C38: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C8: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C9, C10: 18p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3: MBR0520LT1G; D_SOD-123
D4, D5, D7: YELLOW; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D6: GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D8, D9, D18, D19: BLUE; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D10, D20, D21: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J4: RJ12; E5566-Q0LK22-L
J2: Conn_Coaxial_Power; BarrelJack_Horizontal
J3: Conn_02x03_Odd_Even; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
J5, J12: AudioJack3_SwitchTR; Jack_3.5mm_Ledino_KB3SPRS_Horizontal
J6: SJ; PinHeader_1x02_P2.54mm_Vertical
J7, J8: Conn_01x01; SolderWirePad_1x01_SMD_5x10mm
JP1: Test 3.3V; PinHeader_1x02_P2.54mm_Vertical
JP2: Test 12V; PinHeader_1x02_P2.54mm_Vertical
JP3: IO1; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
JP4: IO2; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
JP8: IO3; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
JP9, JP13, JP14: IO4; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
Q1, Q2, Q5, Q6, Q7, Q8: ZXMS6004; SOT-23
Q3: IPB80N03S4L-03; TO-263-2
R1, R2, R10, R15, R17, R20, R21, R52, R53, R54, R55: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3, R4: 22; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5, R8, R19: 100; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6, R12, R50: 4.7k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R7, R9, R11, R13, R14, R16, R51: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R18: 1M; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: DS18B20; MSOP-8_3x3mm_P0.65mm
U2: ATMEGA32U4-AU; TQFP-44_10x10mm_P0.8mm
X1: MINI-USB-SCHIELD-32005-201; USB_Mini-B_Lumberg_2486_01_Horizontal
Y1: Crystal; Crystal_SMD_0603-2Pin_6.0x3.5mm_HandSoldering

Connections:
3.3V: C7.1, JP1.1, R1.1, R2.1, R5.1, R8.1, R9.1, R10.1, R11.1, R12.1, R16.1, U1.8 (VDD), U2.2 (UVCC), U2.14 (VCC), U2.24 (AVCC), U2.34 (VCC1), U2.44 (AVCC1); also elsewhere on the board
12V: C4.1, C5.1, D2.2 (A), J1.1, J2.1 (In), J4.1, J7.1, JP2.1, JP3.1, JP4.1, JP8.1, JP9.1, JP13.1, JP14.1; also elsewhere on the board
/A3: U2.39 (PF4(ADC4/TCK))
/RX: U2.20 (PD2(INT2/RXD1))
A0: U2.36 (PF7(ADC7(TDI)); also elsewhere on the board
A1: U2.37 (PF6(ADC6/TDO)); also elsewhere on the board
A2: R13.2, U2.38 (PF5(ADC5/TMS))
A4: C38.1, Q8.1 (G), R54.1, U2.40 (PF1(ADC1))
A5: R51.2, U2.41 (PF0(ADC0))
A6: Q5.1 (G), R52.1, U2.25 (PD4(ICP1/ADC8))
AREF: C11.1, U2.42 (AREF)
D5: Q2.1 (G), R20.1, U2.31 (PC6(OC3A/~OC4A))
D6: R19.2, R21.1, U2.27 (PD7(OC4D/ADC10/T0))
D7: R7.2, U2.1 (PE6(INT.6/AIN0))
D8: U2.28 (PB4(ADC11)); also elsewhere on the board
D9: U2.29 (PB5(OC1A/ADC12/~OC4B)); also elsewhere on the board
D10: Q1.1 (G), R17.1, U2.30 (PB6(OC1B/OC4B/ADC13))
D11: C35.1, Q7.1 (G), R55.1, U2.12 (PB7(OC0A/OC1C/RTS))
D12: Q6.1 (G), R53.1, U2.26 (PD6(T1/ADC9/~OC4D))
D13: R14.1, U2.32 (PC7(ICP3/CLK0/OC4A))
GND: C1.2, C2.2, C3.1, C4.2, C5.2, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C34.2, C35.2, C38.2, D6.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), J1.4, J1.6, J2.2 (Ext), J3.6, J4.4, J4.6, J5.R, J6.2, J12.R, JP1.2, JP2.2, Q1.2 (S), Q2.2 (S), Q3.3 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), R15.1, U1.4 (GND), U2.5 (UGND), U2.15 (GND), U2.23 (GND1), U2.35 (GND2), U2.43 (GND3), X1.5; also elsewhere on the board
MISO: J3.1, U2.11 (PB3(PDO/MISO)); also elsewhere on the board
MOSI: J3.4, U2.10 (PB2(PDI/MOSI)); also elsewhere on the board
unnamed: C8.1, U2.6 (UCAP)
unnamed: C9.1, R18.1, U2.17 (XTAL1), Y1.1
unnamed: C10.1, R18.2, U2.16 (XTAL2), Y1.2
unnamed: C34.1, Q3.1 (G), R19.1
unnamed: D1.2 (A), J3.2
unnamed: D4.2 (A), R9.2
unnamed: D5.2 (A), R11.2
unnamed: D6.2 (A), R14.2
unnamed: D7.2 (A), R16.2
unnamed: D8.2 (A), R17.2
unnamed: D9.2 (A), R20.2
unnamed: D10.2 (A), R21.2
unnamed: D18.2 (A), R52.2
unnamed: D19.2 (A), R53.2
unnamed: D20.2 (A), R54.2
unnamed: D21.2 (A), R55.2
unnamed: J5.S, R5.2, R6.1
unnamed: J5.T, R6.2, R7.1
unnamed: J8.1, Q3.2 (D), Q3.4, Q3.5, Q3.6, Q3.7, Q3.8, Q3.9, Q3.10, Q3.11, Q3.12, Q3.13, Q3.14, Q3.15
unnamed: J12.S, R8.2, R50.1
unnamed: J12.T, R50.2, R51.1
unnamed: JP3.2, Q1.3 (D)
unnamed: JP4.2, Q2.3 (D)
unnamed: JP8.2, Q5.3 (D)
unnamed: JP9.2, Q6.3 (D)
unnamed: JP13.2, Q7.3 (D)
unnamed: JP14.2, Q8.3 (D)
unnamed: R3.2, X1.2
unnamed: R4.2, X1.3
unnamed: R12.2, R13.1, U1.1 (DQ)
unnamed: R15.2, U2.33 (PE2(~HWB))
RESET: C6.2, J3.5, J6.1, R10.2, U2.13 (/RESET)
RXLED: D5.1 (K), U2.8 (PB0(SS))
SCK: J3.3, U2.9 (PB1(SCK)); also elsewhere on the board
SCL: J1.2, J4.2, R1.2, U2.18 (PD0(INT0/OC0B/SCL))
SDA: J1.3, J4.3, R2.2, U2.19 (PD1(INT1/SDA))
TX: D7.1 (K), U2.21 (PD3(INT3/TXD1)); also elsewhere on the board
TXLED: D4.1 (K), U2.22 (PD5(XCK/CTS))
USB_N: R3.1, U2.3 (D-)
USB_P: R4.1, U2.4 (D+)
VDD: C1.1, C2.1, D1.1 (K), D2.1 (K), D3.1 (K); also elsewhere on the board
VUSB: C3.2, D3.2 (A), U2.7 (VBUS), X1.1

Notes on the sheet:
Flash Memory
FAN
USB
COM LEDS
3.3V LDO
PID
Power Supply
I/O
8MHz
MINI-USB
5V Protect
Stepper
ATMega32u4
One wire
ERROR
I2C
Load cell 24bits

Parts:
C15: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
IC1: SST26VF064B-104V; SOIJ-8_5.3x5.3mm_P1.27mm
R26: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R27, R28: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Connections:
3.3V: C15.1, IC1.3 (~WP~), IC1.7 (HOLD), IC1.8 (VDD), R28.1; also elsewhere on the board
GND: C15.2, IC1.4 (VSS); also elsewhere on the board
MISO: IC1.2 (SO); also elsewhere on the board
MOSI: IC1.5 (SI), R28.2; also elsewhere on the board
unnamed: IC1.1 (~CE~), R26.1
unnamed: IC1.6 (SCK), R27.2
SCK: R27.1; also elsewhere on the board
TX: R26.2; also elsewhere on the board

Notes on the sheet:
SCK
VCC
Flash Memory
GND
HOLD
MOSI
MISO

Parts:
C12: 22n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C13: 10u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C14: 22u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D11, D13: GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D12: MBR0520LT1G; D_SOD-123
L1: 4.7u; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R22: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R23: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R24: 49.9k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R25: 16.23k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U3: ACT4088; SOT-23-6_Handsoldering

Connections:
3.3V: C14.1, L1.2, R23.1, R24.1; also elsewhere on the board
GND: C13.2, C14.2, D11.1 (K), D12.2 (A), D13.1 (K), R25.1, U3.5 (G); also elsewhere on the board
unnamed: C12.1, U3.6 (BST)
unnamed: C12.2, D12.1 (K), L1.1, U3.1 (SW)
unnamed: D11.2 (A), R22.2
unnamed: D13.2 (A), R23.2
unnamed: R24.2, R25.2, U3.4 (FB)
VDD: C13.1, R22.1, U3.2 (IN); also elsewhere on the board

Notes on the sheet:
3.3V LDO
LDPW12
3.3v: 16.23k 5v: 9.64k
Power LEDS
The inductor's DC resistance should be less than 250 mΩ. The input capacitor, electrolytic, or ceramics with low ESR should be used.
LDPW3

Parts:
C16, C18, C19, C20: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C17, C21: 10u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J9: SJ; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
JP5: M05PTH; PinHeader_1x05_P2.54mm_Vertical
JP6: M02PTH; PinHeader_1x02_P2.54mm_Vertical
Q4: TRANSISTOR_PNPMMBT4403; SOT-23_Handsoldering
R29: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R30: 20k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R31: 8.2k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R32, R33: 100; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SJ1: JUMPER-PAD-2-NC_BY_TRACE; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
U4: (no value)

Connections:
3.3V: C20.1, C21.1, Q4.2 (E), R29.1, U4.1 (VSUP), U4.16 (DVDD); also elsewhere on the board
/Load cell 24bits ADC/LGND: C16.2, C17.2, C18.1, R31.2, SJ1.2, U4.5 (AGND)
A0: U4.11 (PD_SCK); also elsewhere on the board
A1: U4.12 (DOUT); also elsewhere on the board
GND: C20.2, C21.2, J9.1, JP5.1, JP5.4, SJ1.1, U4.14 (XI); also elsewhere on the board
unnamed: C16.1, C17.1, JP5.5, Q4.3 (C), R30.1, U4.3 (AVDD)
unnamed: C18.2, U4.6 (VBG)
unnamed: C19.1, R32.1, U4.7 (INA-)
unnamed: C19.2, R33.1, U4.8 (INA+)
unnamed: J9.2, R29.2, U4.15 (RATE)
unnamed: JP5.2, R33.2
unnamed: JP5.3, R32.2
unnamed: JP6.1, U4.10 (INB+)
unnamed: JP6.2, U4.9 (INB-)
unnamed: Q4.1 (B), U4.2 (BASE)
unnamed: R30.2, R31.1, U4.4 (VFB)

Notes on the sheet:
Red Black White Yellow
Default: Closed - Data rate set to 10SPS Open jumper to set to 80SPS Increases noise per read
E+ E- A- A+ Shield
Load Cell 24bits
VBG=1.25V
VCC: 2.7 - 5.5V IO: 2.7 - 5.5V

Parts:
C22, C23, C26: 220n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C24, C27, C28, C29, C32, C33, C36, C37: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C25: 100u; CP_Elec_8x10
C30, C31: 1n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D14, D15, D16, D17: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
IC2: DRV8811; HTSSOP-28-1EP_4.4x9.7mm_P0.65mm_EP3.4x9.5mm_ThermalVias
J10, J11: SJ; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
JP7, JP10, JP11, JP12: JP4E; PinHeader_1x04_P2.54mm_Vertical
R34, R36, R39, R40, R42, R49: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R41: 3.3k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R43, R44: 0.1; R_2010_5025Metric_Pad1.52x2.65mm_HandSolder
R45, R46, R48: 47k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R47: 180; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Connections:
3.3V: C27.1, IC2.10 (VCC), IC2.27 (SLEEP), R39.1, R40.1, R41.1, R42.1; also elsewhere on the board
12V: C23.1, C24.1, C25.1, C36.1, C37.1, IC2.15 (VMB), IC2.28 (VMA); also elsewhere on the board
/Stepper/AOUT1: D14.2 (A), D15.1 (K), IC2.4 (AOUT1), JP7.1, JP10.1, JP11.1, JP12.1
/Stepper/AOUT2: IC2.25 (AOUT2), JP7.2, JP10.2, JP11.2, JP12.2, R34.2
/Stepper/BOUT1: IC2.11 (BOUT1), JP7.3, JP10.3, JP11.3, JP12.3, R36.2
/Stepper/BOUT2: D16.2 (A), D17.1 (K), IC2.18 (BOUT2), JP7.4, JP10.4, JP11.4, JP12.4
D8: IC2.3 (DIR); also elsewhere on the board
D9: IC2.19 (STEP); also elsewhere on the board
GND: C22.1, C24.2, C25.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C36.2, C37.2, IC2.7 (GND), IC2.21 (GND1), IC2.26 (ENABLE), IC2.29 (GND2), J10.2, J11.2, R43.2, R44.2, R45.2, R46.2, R47.2, R48.2, R49.2; also elsewhere on the board
unnamed: C22.2, IC2.20 (VGD)
unnamed: C23.2, IC2.22 (VCP)
unnamed: C26.1, IC2.23 (CP1)
unnamed: C26.2, IC2.24 (CP2)
unnamed: C28.1, IC2.14 (ISENB), R43.1
unnamed: C29.1, IC2.1 (ISENA), R44.1
unnamed: C30.1, IC2.6 (RCA), R45.1
unnamed: C31.1, IC2.9 (RCB), R46.1
unnamed: C32.1, IC2.8 (VREF), R41.2, R47.1
unnamed: C33.1, IC2.5 (DECAY), R42.2, R48.1
unnamed: D14.1 (K), D15.2 (A), R34.1
unnamed: D16.1 (K), D17.2 (A), R36.1
unnamed: IC2.12 (USM1), J10.1, R39.2
unnamed: IC2.13 (USM0), J11.1, R40.2
unnamed: IC2.16 (SR), R49.1

Notes on the sheet:
50 V
Rlim Approx. 180 Ohms
Stepper
C25: 399-6104-ND
S2_STEP
BLUE RED GREEN BLACK
CT6EP103-ND
1 W 2010
S2_DIR
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
Board: 2 copper layers, 100.0 x 87.0 mm, 159 parts (0 on the bottom side), 101 nets.

## KiCad design pcb/loadCell/loadCell.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2, J3: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical_SMD_Pin1Left
J4: Conn_01x05_Male; PinHeader_1x05_P2.54mm_Vertical

Connections:
GND: J4.1
unnamed: J1.1, J2.1, J3.1, J4.2
unnamed: J1.2, J2.2, J3.2, J4.3
unnamed: J1.3, J2.3, J3.3, J4.4
unnamed: J1.4, J2.4, J3.4, J4.5

Board: 2 copper layers, 35.6 x 35.6 mm, 8 parts (0 on the bottom side), 4 nets.

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
