# Repository Hackuarium/bioreactor (continued)

## KiCad design pcb/pHMeter/pHMeter.kicad_pcb

Board: 2 copper layers, 100.0 x 87.0 mm, 148 parts (2 on the bottom side), 95 nets, no tracks yet.

Parts:
C1, C2, C3, C4, C5, C6, C8, C10, C12, C22, C33: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C7, C11, C19, C20, C21, C23, C31: 10u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C9, C24, C25: 22u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C13, C14: 22pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C15, C16, C17, C18, C26, C28, C30: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C27, C29: 10uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2: D; D_SOD-123
D3, D4, D5, D14: D_Schottky; D_SOD-123
D6: MB2S; TO-269AA
D7, D8, D9, D10, D11, D12, D13, D17, D18: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D15, D16: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D19, D20: TX; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
DS1: WC1602A
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_02x03_Odd_Even; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
J2, J3: Conn_Coaxial_Power; BNC_TEConnectivity_1478204_Vertical
J4, J6: AudioJack3_SwitchTR; Jack_3.5mm_Ledino_KB3SPRS_Horizontal
J5: RJ12; E5566-Q0LK22-L
J7, J8: SJ; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP1, JP2: JP1E; PinHeader_1x02_P2.54mm_Vertical
JP3: acidic; PinHeader_1x02_P2.54mm_Vertical
JP4: alkaline; PinHeader_1x02_P2.54mm_Vertical
JP5: Bat; PinHeader_1x02_P2.54mm_Vertical
JP6: IO3; PinHeader_1x02_P2.54mm_Vertical
JP7: IO4; PinHeader_1x02_P2.54mm_Vertical
L2: 3.9u; L_TDK_SLF6028
Q1, Q2, Q4, Q5: ZXMS6004; SOT-23
Q3: DMP1045; SOT-23
R1, R6, R7, R8, R9, R10, R12, R17, R18, R19, R22, R40, R42, R43, R44, R49, R50, R55, R56: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2, R3, R4, R13, R16, R20, R21, R23, R24, R25, R26, R27, R28, R29, R30, R34, R36, R37, R39, R41, R47, R48: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5: 22k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R11: 56.2k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R14, R15: 22; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R31: 0; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R32, R33, R53, R54: 100; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R35, R38, R45: 1M; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R46: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R51, R52: 4.7k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RV1: 10k; Potentiometer_Bourns_3339P_Vertical_HandSoldering
SJ1: JUMPER-PAD-2-NC_BY_TRACE; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
SW1: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
TP1: TestPoint; TestPoint_Pad_D1.0mm
U1, U2: TLV6004PW; TSSOP-14_4.4x5mm_P0.65mm
U3: ATMEGA32U4-AU; TQFP-44_10x10mm_P0.8mm
U4: MCP1703A; SOT-23
U5: AP63203WU-7; TSOT-23-6
U6: HX711; SOIC-16_3.9x9.9mm_P1.27mm
U7: SST26VF064B; SOIJ-8_5.3x5.3mm_P1.27mm
U9: MCP73811T; SOT-23-5
X1: MINI-USB-SCHIELD-32005-201; USB_Mini-B_Lumberg_2486_01_Horizontal
Y1: Crystal; Crystal_SMD_0603-2Pin_6.0x3.5mm_HandSoldering

Connections:
3.3V: C1.1, C10.1, C17.1, C24.2, C25.2, C26.1, C27.1, C28.1, C29.1, C31.1, JP1.1, L2.2, R3.2, R21.1, R23.1, R24.1, R25.1, R28.1, R34.1, R40.1, R41.1, R42.2, R53.2, R54.2, R55.2, R56.2, U1.4, U2.4, U3.2, U3.14, U3.24, U3.34, U3.44, U5.1, U6.1, U6.3, U6.16, U7.3, U7.7, U7.8
12V: C20.1, J5.1, JP2.1, JP3.1, JP4.1, JP6.1, JP7.1, R16.1, U4.3
/24bits ADC/LGND: C28.2, C29.2, C30.1, SJ1.2, U6.4, U6.5, U6.7
A3: C33.1, R38.2, R45.1, U3.39
A5: R29.1, R30.2, U3.41, U6.12
A6: DS1.4, U3.25
A+: R22.2, U2.14, U6.8
AREF: C16.1, U3.42
B+: C9.1, R11.1, R13.2, U6.10
B-: R13.1, U1.6, U1.7, U6.9
D5: DS1.13, U3.31
D6: DS1.6, U3.27
D7: R49.1, R50.1, U3.1, U6.11
D8: Q1.1, R26.1, U3.28
D9: DS1.11, U3.29
D10: DS1.14, U3.30
D11: DS1.12, U3.12
D12: Q2.1, Q4.1, Q5.1, R27.1, R47.1, R48.1, U3.26
D13: DS1.2, R20.1, R31.1, R32.1, U3.32
GND: C1.2, C2.1, C3.2, C6.2, C7.2, C9.2, C10.2, C11.2, C13.2, C14.2, C15.1, C16.2, C17.2, C18.2, C19.2, C20.2, C21.1, C23.2, C24.1, C25.1, C26.2, C27.2, C31.2, C33.2, D7.1, D8.1, D12.1, D13.1, D15.1, D16.1, D17.1, D18.1, DS1.1, DS1.5, DS1.16, J1.6, J2.2, J4.R, J5.4, J5.6, J6.R, J7.2, J8.1, JP1.2, JP2.2, JP5.2, Q1.3, Q2.3, Q4.3, Q5.3, R1.2, R2.2, R4.2, R8.1, R10.1, R12.1, R33.2, R36.1, R37.1, R45.2, R46.2, SJ1.1, SW1.C, U1.11, U2.11, U3.5, U3.15, U3.23, U3.35, U3.43, U4.1, U5.4, U6.14, U7.4, U9.2, X1.5
HWB: R36.2, U3.33
MISO: J1.1, U3.11, U7.2
MOSI: J1.4, R42.1, U3.10, U7.5
unnamed: C2.2, C4.2, R1.1, U2.3
unnamed: C3.1, R3.1, R4.1, U1.3, U1.5
unnamed: C4.1, R6.2
unnamed: C5.1, D1.2, D2.1
unnamed: C5.2, R5.1, R6.1, R7.2, U2.1
unnamed: C6.1, C7.1, D5.2, U4.2
unnamed: C8.1, R9.1, U2.7
unnamed: C8.2, R10.2, U2.10
unnamed: C12.1, D6.1, R17.1, R19.1
unnamed: C12.2, D6.2, R17.2, R18.1
unnamed: C13.1, R35.1, U3.17, Y1.1
unnamed: C14.1, R35.2, U3.16, Y1.2
unnamed: C18.1, U3.6
unnamed: C22.1, L2.1, U5.5
unnamed: C22.2, U5.6
unnamed: C23.1, JP5.1, Q3.3, R38.1, U9.3
unnamed: C30.2, U6.6
unnamed: D1.1, D2.2, R2.1, R5.2, U2.2
unnamed: D3.2, J1.2
unnamed: D6.3, U2.8
unnamed: D6.4, R12.2, U2.9
unnamed: D7.2, R16.2
unnamed: D8.2, R20.2
unnamed: D9.2, R21.2
unnamed: D10.2, R23.2
unnamed: D11.2, R24.2
unnamed: D12.2, R27.2
unnamed: D13.2, R26.2
unnamed: D15.2, R39.2
unnamed: D16.2, R40.2
unnamed: D17.2, R47.2
unnamed: D18.2, R48.2
unnamed: D19.1, J4.S, R51.2, R53.1
unnamed: D19.2, R55.1
unnamed: D20.1, J6.S, R52.2, R54.1
unnamed: D20.2, R56.1
unnamed: DS1.3, RV1.2
unnamed: DS1.15, R31.2
unnamed: J2.1, R9.2, U2.6
unnamed: J3.1, U1.10
unnamed: J3.2, U1.1, U1.2
unnamed: J4.T, R49.2, R51.1
unnamed: J6.T, R50.2, R52.1
unnamed: J8.2, R41.2, U6.15
unnamed: JP3.2, Q2.2
unnamed: JP4.2, Q1.2
unnamed: JP6.2, Q4.2
unnamed: JP7.2, Q5.2
unnamed: R7.1, R8.2, TP1.1, U2.5
unnamed: R11.2, U1.8, U1.9
unnamed: R14.2, X1.2
unnamed: R15.2, X1.3
unnamed: R18.2, U2.12
unnamed: R19.2, R22.1, U2.13
unnamed: R30.1, U9.1
unnamed: R32.2, RV1.1
unnamed: R33.1, RV1.3
unnamed: R37.2, U9.5
unnamed: R43.2, U7.6
unnamed: R44.1, U7.1
RESET: C15.2, J1.5, J7.1, R34.2, U3.13
RXLED: D9.1, U3.8
SCK: J1.3, R43.1, U3.9
SCL: J5.2, R28.2, U3.18
SDA: J5.3, R25.2, U3.19
TX: D11.1, R44.2, U3.21
TXLED: D10.1, U3.22
USB_N: R14.1, U3.3
USB_P: R15.1, U3.4
VBAT: C19.1, D14.1, Q3.2, R39.1, U5.2, U5.3
VDD: C21.2, D3.1, D4.1, D5.1, D14.2, Q3.1, R29.2, R46.1, U9.4
VUSB: C11.1, D4.2, U3.7, X1.1

## Commit log

2020-01-10 create feature definition document
2020-01-19 feat: add pcb and copy of arduino
2020-02-02 feat: add arduino tests
2020-02-02 update BioMain
2020-02-02 chore:: add docs
2020-02-16 fix: update arduino code
2020-02-16 chore: update libino
2020-02-16 fix(pcb): wrong pad connected in bsp75
2020-02-16 feat: add magnet CAD
2020-02-16 chore: remove empty spaces
2020-02-16 feat: working on case in openscad
2020-02-16 feat: openscad case
2020-02-17 fix: remove resistor on the GND of onewire
2020-03-05 fix: pcb
2020-05-11 Update libino
2020-05-18 chore: enhance arduino docs
2020-06-04 change readme.d to git clone this project and add schematic in Kicad for pHmeter
2020-06-04 fix: sst memory
2020-06-05 fix: put back file fp-info-cache
2020-06-05 chore: update libino dependency
2020-06-05 doc: update readme
2020-06-05 refactor: arduino ide code to platformio project
2020-06-05 refactor: move libraries from libino to lib
2020-06-05 chore: trying to make dependencies work
2020-06-05 create library folder for pHmeter and update SST25VF064C library
2020-06-05 update 3.sch in pHmeter PCB to change ACT4088 for AP62303 (3.3 V compatible)
2020-06-06 Information doc for changes ACT4088 to AP63203 3.3 V coverter buck
2020-06-07 Update libraries into pHmeter
2020-06-08 Add LCD1602, I2C and Alk/Acid Foods into pHmeter
2020-06-09 change power supply for LCD1602
2020-06-09 pcb and footprints
2020-06-10 update pcb
2020-06-10 feat: add parameter PARAM_STEPPER_WAIT
2020-06-10 pcb phMeter
2020-06-11 doc (arduino): enhance flags comments
2020-06-11 doc: readme minor change (fix doc link)
2020-06-11 Update pHMeter pcb
2020-06-12 Update sch & pcb
2020-06-12 Update pcb pHmeter and doc
2020-06-13 feat(pcb): adding 2 I/O, 1 tmp sensor, 4 stepper
2020-06-13 New Li-Po
2020-06-13 feat: add 2 IO, 1 one wire, fan and 3 stepper output. Closes: #20 #11 #9 #4
2020-06-14 update pcb pHMeter
2020-06-14 doc: improve pinMapping
2020-06-14 doc: fix pin mapping
2020-06-16 feat: add ramp on stepper
2020-06-20 doc: brainstorming on program steps
2020-06-27 fix: improve label on pcb
2020-06-27 feat: improve stepper ramp
2020-08-02 fix: Rlim value
2020-08-02 chore: remove pHmeter from this project
2020-08-03 fix: close https://github.com/Hackuarium/bioreactor/issues/32
2020-08-08 feat(Arduino): add second external temperature probe
2020-08-08 feat(Arduino): add fan control
2020-08-08 chore(Arduino): rename variables
2020-08-08 chore(Arduino): rename Thread pump to Thread output
2020-08-08 fix: remove LED from onewire sensors
2020-08-18 feat(arduino): update the code to deal with steps and pipeline
2020-08-18 fix: suppress leds for onewire
2020-08-18 docs: improve steps documentation
2020-08-22 chore: remove case and more to laser-cut-box
2020-08-22 chore: fix comments
2020-08-22 chore: remove laset-cut-box
2020-08-25 Changed MJH6284 darlington transistor for two PB80N03S4L03 MOSFETs
2020-08-26 Update PCB wih new PID control
2020-08-26 Created ERROR LED & FAN LED
2020-08-26 Deleted unnecessary resistor and add capacitors to VMA & VMB DRV8811 (issue #28)
2020-08-27 New place for ERROR and add transistor for LED-strip (issue #37)
2020-08-28 fix: pcb overlap
2020-08-31 Create Turner_MasterThesis_Yeast
    Description of project done by Tomas Turner in his Master Thesis using the Open Source bioreactor
2020-08-31 Solved debug error for PID
2020-08-31 Solved DRC error in PID
2020-09-06 chore: move values labels
2020-09-06 Solved unconnected pins
2020-09-06 chore: refill gnd
2020-09-26 feat: add small loading cell pcb
2020-09-26 chore: format update
2020-09-27 feat: add new magnet support in openscad
2020-09-27 fix: spelling mistake
2020-10-04 feat: update magnet and locadingCellSupport
2020-10-07 Add fields to PCBA
2020-10-08 Update 2: Fields for BOM with PCBA manufacturer
2020-10-09 Update 3 - BOM for PCBA
2020-10-09 Update 4 - BOM for PCBA. Ready to check issue #46
2020-10-10 Update 5 - BOM for PCBA. Check 1 issue #46
2020-10-15 Update UCAP for uC 100n -> 1u
2020-10-18 fix: magnet
2020-10-18 feat: red alert and fan control
2020-10-28 Fix: capacitors value for crystal (22p to 18 p)
2021-05-11 docs(BOM): iBOM.html updated
2022-02-22 docs: pin mapping update
2022-02-24 docs: update pin mapping
2022-04-19 feat: update PCB to Kicad 6.0
2022-04-19 feat: Update PCB to Kicad 6.0 stable
2022-04-19 fix: change git to https protocol for libino submodule
2022-08-25 fix: 3D view for HX711 and crystal
    Updated route for Kicad 6.0
2022-11-01 fix: Warnings and errors in Kicad
2022-11-15 docs: solved Add a CITATION.cff file #50
2022-11-16 fix: title in CITATION.cff
2022-11-16 docs: Update CITATION.cff
2022-11-16 docs: update CITATION
2022-11-17 docs: add doi in CITATION.cff
2022-11-17 Update CITATION.cff
    Add link to https://docs.hackuarium.org/docs/bioreactor/
