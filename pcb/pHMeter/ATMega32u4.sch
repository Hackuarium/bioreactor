File: pcb/pHMeter/ATMega32u4.sch (KiCad schematic (older format))
At the start: 15 parts

Commit message: Update libraries into pHmeter
Parts:
- removed JP? (x3): PINHD-1X1, symbol Bertha_main-eagle-import:PINHD-1X1
- removed U?: ATMEGA32U4-AU, symbol Bertha_main-eagle-import:ATMEGA32U4-AU
- added JP? (x2): M02JST-PTH-2, symbol Bertha_main-eagle-import:M02JST-PTH-2
- added U?: ATMEGA32U4-AU, symbol bioreactor:ATMEGA32U4-AU
Connections:
- wire segments 89 -> 90
Changed lines of the file:
@@
 Comment4 ""
 $EndDescr
-$Comp
-L Bertha_main-eagle-import:ATMEGA32U4-AU U?
-U 1 1 5E02C410
-P 4950 2900
-F 0 "U?" H 5000 4886 59  0000 C CNN
-F 1 "ATMEGA32U4-AU" H 5000 4781 59  0000 C CNN
-F 2 "" H 4950 2900 50  0001 C CNN
-F 3 "" H 4950 2900 50  0001 C CNN
-	1    4950 2900
-	1    0    0    -1
-$EndComp
-Text GLabel 6100 1200 2    55   Input ~ 0
+Text GLabel 6100 1200 2    50   Input ~ 0
 A5
-Text GLabel 6100 1300 2    55   Input ~ 0
+Text GLabel 6100 1300 2    50   Input ~ 0
 A4
-Text GLabel 6100 1400 2    55   Input ~ 0
+Text GLabel 6100 1400 2    50   Input ~ 0
 A3
-Text GLabel 6100 1500 2    55   Input ~ 0
+Text GLabel 6100 1500 2    50   Input ~ 0
 A2
-Text GLabel 6100 1600 2    55   Input ~ 0
+Text GLabel 6100 1600 2    50   Input ~ 0
 A1
-Text GLabel 6100 1700 2    55   Input ~ 0
+Text GLabel 6100 1700 2    50   Input ~ 0
 A0
 $Comp
@@
 	0    1    1    0
 $EndComp
-Text GLabel 6000 1825 2    55   Input ~ 0
+Text GLabel 6000 1825 2    50   Input ~ 0
 HWB
 Wire Wire Line
@@
 Wire Wire Line
 	6000 1900 6250 1900
-Text GLabel 6625 1900 2    55   Input ~ 0
+Text GLabel 6625 1900 2    50   Input ~ 0
 GND
 Wire Wire Line
 	6625 1900 6550 1900
-Text GLabel 6100 2000 2    55   Input ~ 0
+Text GLabel 6100 2000 2    50   Input ~ 0
 D7
-Text GLabel 6100 2200 2    55   Input ~ 0
+Text GLabel 6100 2200 2    50   Input ~ 0
 D5
-Text GLabel 6100 2300 2    55   Input ~ 0
+Text GLabel 6100 2300 2    50   Input ~ 0
 D13
-Text GLabel 6100 2500 2    55   Input ~ 0
+Text GLabel 6100 2500 2    50   Input ~ 0
 D11
-Text GLabel 6100 2600 2    55   Input ~ 0
+Text GLabel 6100 2600 2    50   Input ~ 0
 D10
-Text GLabel 6100 2700 2    55   Input ~ 0
+Text GLabel 6100 2700 2    50   Input ~ 0
 D9
-Text GLabel 6100 2800 2    55   Input ~ 0
+Text GLabel 6100 2800 2    50   Input ~ 0
 D8
-Text GLabel 6100 2900 2    55   Input ~ 0
+Text GLabel 6100 2900 2    50   Input ~ 0
 MISO
-Text GLabel 6100 3000 2    55   Input ~ 0
+Text GLabel 6100 3000 2    50   Input ~ 0
 MOSI
 Wire Wire Line
@@
 Wire Wire Line
 	5950 3000 6100 3000
-Text GLabel 6100 3100 2    55   Input ~ 0
+Text GLabel 6100 3100 2    50   Input ~ 0
 SCK
-Text GLabel 6100 3200 2    55   Input ~ 0
+Text GLabel 6100 3200 2    50   Input ~ 0
 RXLED
-Text GLabel 6100 3400 2    55   Input ~ 0
+Text GLabel 6100 3400 2    50   Input ~ 0
 D6
-Text GLabel 6100 3500 2    55   Input ~ 0
+Text GLabel 6100 3500 2    50   Input ~ 0
 D12
-Text GLabel 6100 3600 2    55   Input ~ 0
+Text GLabel 6100 3600 2    50   Input ~ 0
 TXLED
-Text GLabel 6100 3700 2    55   Input ~ 0
+Text GLabel 6100 3700 2    50   Input ~ 0
 A6
-Text GLabel 6100 3800 2    55   Input ~ 0
+Text GLabel 6100 3800 2    50   Input ~ 0
 TX
 Wire Wire Line
@@
 Wire Wire Line
 	6100 3800 5950 3800
-Text GLabel 6100 3900 2    55   Input ~ 0
+Text GLabel 6100 3900 2    50   Input ~ 0
 RX
-Text GLabel 6100 4000 2    55   Input ~ 0
+Text GLabel 6100 4000 2    50   Input ~ 0
 SDA
-Text GLabel 6100 4100 2    55   Input ~ 0
+Text GLabel 6100 4100 2    50   Input ~ 0
 SCL
 Wire Wire Line
@@
 Wire Wire Line
 	6100 4100 5950 4100
-$Comp
-L Bertha_main-eagle-import:PINHD-1X1 JP?
-U 1 1 5E03F8E3
-P 5175 4550
-F 0 "JP?" H 5000 4775 59  0000 L CNN
-F 1 "PINHD-1X1" H 4825 4700 59  0000 L CNN
-F 2 "" H 5175 4550 50  0001 C CNN
-F 3 "" H 5175 4550 50  0001 C CNN
-	1    5175 4550
-	1    0    0    -1
-$EndComp
-Text GLabel 5425 4550 2    55   Input ~ 0
-GND
-Wire Wire Line
-	5075 4550 5425 4550
-Text GLabel 6400 4550 2    55   Input ~ 0
+Text GLabel 5500 4525 2    50   Input ~ 0
+GND
+Text GLabel 5500 4750 2    50   Input ~ 0
 3.3V
-$Comp
-L Bertha_main-eagle-import:PINHD-1X1 JP?
-U 1 1 5E049307
-P 5175 4950
-F 0 "JP?" H 5000 5175 59  0000 L CNN
-F 1 "PINHD-1X1" H 4825 5100 59  0000 L CNN
-F 2 "" H 5175 4950 50  0001 C CNN
-F 3 "" H 5175 4950 50  0001 C CNN
-	1    5175 4950
-	1    0    0    -1
-$EndComp
-Text GLabel 5425 4950 2    55   Input ~ 0
+Text GLabel 5500 4425 2    50   Input ~ 0
 12V
-Wire Wire Line
-	5075 4950 5425 4950
-Wire Wire Line
-	6000 4550 6400 4550
-$Comp
-L Bertha_main-eagle-import:PINHD-1X1 JP?
-U 1 1 5E041434
-P 6100 4550
-F 0 "JP?" H 5950 4775 59  0000 L CNN
-F 1 "PINHD-1X1" H 5775 4700 59  0000 L CNN
-F 2 "" H 6100 4550 50  0001 C CNN
-F 3 "" H 6100 4550 50  0001 C CNN
-	1    6100 4550
-	1    0    0    -1
-$EndComp
-Text GLabel 3925 3850 0    55   Input ~ 0
+Text GLabel 3925 3850 0    50   Input ~ 0
 GND
 Wire Wire Line
@@
 	1    0    0    -1
 $EndComp
-Text GLabel 3375 4200 0    55   Input ~ 0
+Text GLabel 3375 4200 0    50   Input ~ 0
 AREF
-Text GLabel 3375 4700 0    55   Input ~ 0
+Text GLabel 3375 4700 0    50   Input ~ 0
 GND
 Wire Wire Line
@@
 	0    1    1    0
 $EndComp
-Text GLabel 2925 3150 0    55   Input ~ 0
+Text GLabel 2925 3150 0    50   Input ~ 0
 GND
 Wire Wire Line
@@
 	3825 3300 4050 3300
 Connection ~ 3825 3300
-Text GLabel 3950 2800 0    55   Input ~ 0
+Text GLabel 3950 2800 0    50   Input ~ 0
 AREF
 Wire Wire Line
@@
 	0    1    1    0
 $EndComp
-Text GLabel 3925 2400 0    55   Input ~ 0
+Text GLabel 3925 2400 0    50   Input ~ 0
 USB_P
-Text GLabel 3925 2300 0    55   Input ~ 0
+Text GLabel 3925 2300 0    50   Input ~ 0
 USB_N
-Text GLabel 3400 2600 0    55   Input ~ 0
+Text GLabel 3400 2600 0    50   Input ~ 0
 GND
 Wire Wire Line
@@
 Wire Wire Line
 	4050 2300 3925 2300
-Text GLabel 3925 1400 0    55   Input ~ 0
+Text GLabel 3925 1400 0    50   Input ~ 0
 VUSB
 Wire Wire Line
 	3925 1400 4050 1400
-Text GLabel 3925 1625 0    55   Input ~ 0
+Text GLabel 3925 1625 0    50   Input ~ 0
 3.3V
 Wire Wire Line
@@
 	3925 2100 4050 2100
 Connection ~ 3925 1900
-Text GLabel 3825 1825 0    55   Input ~ 0
+Text GLabel 3825 1825 0    50   Input ~ 0
 3.3V
 $Comp
@@
 	0    1    1    0
 $EndComp
-Text GLabel 3400 2000 0    55   Input ~ 0
+Text GLabel 3400 2000 0    50   Input ~ 0
 GND
 Wire Wire Line
@@
 Wire Wire Line
 	3475 2000 3400 2000
-Text GLabel 3650 1125 2    55   Input ~ 0
+Text GLabel 3650 1125 2    50   Input ~ 0
 RESET
 Wire Wire Line
@@
 Wire Wire Line
 	3150 850  3075 850
-Text GLabel 3150 850  2    55   Input ~ 0
+Text GLabel 3150 850  2    50   Input ~ 0
 3.3V
 $Comp
@@
 Wire Wire Line
 	3075 1450 3075 1500
-Text GLabel 3075 1575 0    55   Input ~ 0
+Text GLabel 3075 1575 0    50   Input ~ 0
 GND
 Connection ~ 3300 1200
@@
 	-1   0    0    1
 $EndComp
+$Comp
+L bioreactor:ATMEGA32U4-AU U?
+U 1 1 5EE14089
+P 4950 2900
+F 0 "U?" H 5000 4886 59  0000 C CNN
+F 1 "ATMEGA32U4-AU" H 5000 4781 59  0000 C CNN
+F 2 "" H 4950 2900 50  0001 C CNN
+F 3 "" H 4950 2900 50  0001 C CNN
+	1    4950 2900
+	1    0    0    -1
+$EndComp
+$Comp
+L Bertha_main-eagle-import:M02JST-PTH-2 JP?
+U 1 1 5EE193A9
+P 5050 4425
+F 0 "JP?" H 4922 4422 59  0000 R CNN
+F 1 "M02JST-PTH-2" H 4922 4527 59  0000 R CNN
+F 2 "" H 5050 4425 50  0001 C CNN
+F 3 "" H 5050 4425 50  0001 C CNN
+	1    5050 4425
+	1    0    0    1
+$EndComp
+$Comp
+L Bertha_main-eagle-import:M02JST-PTH-2 JP?
+U 1 1 5EE199A8
+P 5050 4750
+F 0 "JP?" H 4922 4747 59  0000 R CNN
+F 1 "M02JST-PTH-2" H 4922 4852 59  0000 R CNN
+F 2 "" H 5050 4750 50  0001 C CNN
+F 3 "" H 5050 4750 50  0001 C CNN
+	1    5050 4750
+	1    0    0    1
+$EndComp
+Text GLabel 5500 4850 2    50   Input ~ 0
+GND
+Wire Wire Line
+	5500 4425 5350 4425
+Wire Wire Line
+	5350 4525 5500 4525
+Wire Wire Line
+	5500 4750 5350 4750
+Wire Wire Line
+	5500 4850 5350 4850
 $EndSCHEMATC

Commit message: Add LCD1602, I2C and Alk/Acid Foods into pHmeter
Parts:
- removed JP?: M02JST-PTH-2, symbol Bertha_main-eagle-import:M02JST-PTH-2
- removed U?: ATMEGA32U4-AU, symbol bioreactor:ATMEGA32U4-AU
- added U3: ATMEGA32U4-AU, Package_QFP:TQFP-44_10x10mm_P0.8mm, symbol bioreactor:ATMEGA32U4-AU
- gave numbers to parts that had none: 12
Connections:
- net 3.3V: now also U3.14 (VCC), U3.2 (UVCC), U3.24 (AVCC), U3.34 (VCC1), U3.44 (AVCC1)
- net A0: now also U3.36 (PF7(ADC7(TDI))
- net A1: now also U3.37 (PF6(ADC6/TDO))
- net A2: now also U3.38 (PF5(ADC5/TMS))
- net A3: now also U3.39 (PF4(ADC4/TCK))
- net A4: now also U3.40 (PF1(ADC1))
- net A5: now also U3.41 (PF0(ADC0))
- net A6: now also U3.25 (PD4(ICP1/ADC8))
- net AREF: now also U3.42 (AREF)
- net D10: now also U3.30 (PB6(OC1B/OC4B/ADC13))
- net D11: now also U3.12 (PB7(OC0A/OC1C/RTS))
- net D12: now also U3.26 (PD6(T1/ADC9/~OC4D))
- net D13: now also U3.32 (PC7(ICP3/CLK0/OC4A))
- net D5: now also U3.31 (PC6(OC3A/~OC4A))
- net D6: now also U3.27 (PD7(OC4D/ADC10/T0))
- net D7: now also U3.1 (PE6(INT.6/AIN0))
- net D8: now also U3.28 (PB4(ADC11))
- net D9: now also U3.29 (PB5(OC1A/ADC12/~OC4B))
- net GND: now also U3.15 (GND), U3.23 (GND1), U3.35 (GND2), U3.43 (GND3), U3.5 (UGND)
- net HWB: now also U3.33 (PE2(~HWB))
- net MISO: now also U3.11 (PB3(PDO/MISO))
- net MOSI: now also U3.10 (PB2(PDI/MOSI))
- net RESET: now also U3.13 (/RESET)
- net RX: now also U3.20 (PD2(INT2/RXD1))
- net RXLED: now also U3.8 (PB0(SS))
- net SCK: now also U3.9 (PB1(SCK))
- net SCL: now also U3.18 (PD0(INT0/OC0B/SCL))
- net SDA: now also U3.19 (PD1(INT1/SDA))
- net TX: now also U3.21 (PD3(INT3/TXD1))
- net TXLED: now also U3.22 (PD5(XCK/CTS))
- net USB_N: now also U3.3 (D-)
- net USB_P: now also U3.4 (D+)
- net VUSB: now also U3.7 (VBUS)
- net at C13.1, R30.1, X2.P$2: now also U3.17 (XTAL1)
- net at C14.1, R30.2, X2.P$1: now also U3.16 (XTAL2)
- net at C18.1: now also U3.6 (UCAP)
Other:
- moved on the sheet: JP5
Changed lines of the file:
@@
 A0
 $Comp
-L Device:R R?
+L Device:R R31
 U 1 1 5E02DBA6
 P 6400 1900
-F 0 "R?" V 6325 1900 50  0000 C CNN
+F 0 "R31" V 6325 1900 50  0000 C CNN
 F 1 "10k" V 6400 1900 50  0000 C CNN
 F 2 "" V 6330 1900 50  0001 C CNN
@@
 Wire Wire Line
 	6100 4100 5950 4100
-Text GLabel 5500 4525 2    50   Input ~ 0
-GND
-Text GLabel 5500 4750 2    50   Input ~ 0
+Text GLabel 5525 4400 2    50   Input ~ 0
 3.3V
-Text GLabel 5500 4425 2    50   Input ~ 0
-12V
 Text GLabel 3925 3850 0    50   Input ~ 0
 GND
@@
 	4000 3850 4000 3800
 $Comp
-L Device:C C?
+L Device:C C16
 U 1 1 5E060188
 P 3375 4450
-F 0 "C?" H 3490 4496 50  0000 L CNN
+F 0 "C16" H 3490 4496 50  0000 L CNN
 F 1 "100nF" H 3490 4405 50  0000 L CNN
 F 2 "" H 3413 4300 50  0001 C CNN
@@
 GND
 Wire Wire Line
-	3375 4200 3375 4300
-Wire Wire Line
 	3375 4600 3375 4700
 $Comp
-L Device:R R?
+L Device:R R30
 U 1 1 5E06947C
 P 3825 3150
-F 0 "R?" V 3925 3025 50  0000 L CNN
+F 0 "R30" V 3925 3025 50  0000 L CNN
 F 1 "1M" V 3825 3100 50  0000 L CNN
 F 2 "" V 3755 3150 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Bertha_main-eagle-import:XTALNX6035 X?
+L Bertha_main-eagle-import:XTALNX6035 X2
 U 1 1 5E06AC4E
 P 3525 3150
-F 0 "X?" V 3775 3250 50  0000 R CNN
+F 0 "X2" V 3775 3250 50  0000 R CNN
 F 1 "XTALNX6035" V 3225 3375 50  0000 R CNN
 F 2 "" H 3525 3150 50  0001 C CNN
@@
 8MHz\n
 $Comp
-L Device:C C?
+L Device:C C13
 U 1 1 5E06D522
 P 3125 3050
-F 0 "C?" V 2925 3050 50  0000 C CNN
+F 0 "C13" V 2925 3050 50  0000 C CNN
 F 1 "22pF" V 3000 3050 50  0000 C CNN
 F 2 "" H 3163 2900 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:C C?
+L Device:C C14
 U 1 1 5E06E8A5
 P 3125 3250
-F 0 "C?" V 3325 3250 50  0000 C CNN
+F 0 "C14" V 3325 3250 50  0000 C CNN
 F 1 "22pF" V 3250 3275 50  0000 C CNN
 F 2 "" H 3163 3100 50  0001 C CNN
@@
 	4050 2800 3950 2800
 $Comp
-L Device:C C?
+L Device:C C18
 U 1 1 5E07E1BC
 P 3625 2600
-F 0 "C?" V 3575 2775 50  0000 C CNN
+F 0 "C18" V 3575 2775 50  0000 C CNN
 F 1 "100nF" V 3675 2775 50  0000 C CNN
 F 2 "" H 3663 2450 50  0001 C CNN
@@
 3.3V
 $Comp
-L Device:C C?
+L Device:C C17
 U 1 1 5E0937A1
 P 3625 2000
-F 0 "C?" V 3825 2000 50  0000 C CNN
+F 0 "C17" V 3825 2000 50  0000 C CNN
 F 1 "100nF" V 3750 2000 50  0000 C CNN
 F 2 "" H 3663 1850 50  0001 C CNN
@@
 3.3V
 $Comp
-L Device:R R?
+L Device:R R29
 U 1 1 5E0BADDD
 P 3075 1000
-F 0 "R?" V 3175 875 50  0000 L CNN
+F 0 "R29" V 3175 875 50  0000 L CNN
 F 1 "10k" V 3075 925 50  0000 L CNN
 F 2 "" V 3005 1000 50  0001 C CNN
@@
 	3300 1200 3600 1200
 $Comp
-L Bertha_main-eagle-import:SJ J?
+L Bertha_main-eagle-import:SJ J7
 U 1 1 5E0A3DEB
 P 3075 1350
-F 0 "J?" V 3000 1050 59  0000 L CNN
+F 0 "J7" V 3000 1050 59  0000 L CNN
 F 1 "SJ" V 3125 1175 59  0000 L CNN
 F 2 "" H 3075 1350 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:C C?
+L Device:C C15
 U 1 1 5E0A09B6
 P 3300 1350
-F 0 "C?" H 3150 1275 50  0000 C CNN
+F 0 "C15" H 3150 1275 50  0000 C CNN
 F 1 "100nF" H 3175 1450 50  0000 C CNN
 F 2 "" H 3338 1200 50  0001 C CNN
@@
 $EndComp
 $Comp
-L bioreactor:ATMEGA32U4-AU U?
-U 1 1 5EE14089
+L Bertha_main-eagle-import:M02JST-PTH-2 JP5
+U 1 1 5EE199A8
+P 5075 4400
+F 0 "JP5" H 4947 4397 59  0000 R CNN
+F 1 "M02JST-PTH-2" H 4947 4502 59  0000 R CNN
+F 2 "" H 5075 4400 50  0001 C CNN
+F 3 "" H 5075 4400 50  0001 C CNN
+	1    5075 4400
+	1    0    0    1
+$EndComp
+Text GLabel 5525 4500 2    50   Input ~ 0
+GND
+Wire Wire Line
+	5525 4400 5375 4400
+Wire Wire Line
+	5525 4500 5375 4500
+Wire Wire Line
+	3375 4300 3375 4200
+$Comp
+L bioreactor:ATMEGA32U4-AU U3
+U 1 1 5EE17B1A
 P 4950 2900
-F 0 "U?" H 5000 4886 59  0000 C CNN
+F 0 "U3" H 5000 4886 59  0000 C CNN
 F 1 "ATMEGA32U4-AU" H 5000 4781 59  0000 C CNN
-F 2 "" H 4950 2900 50  0001 C CNN
-F 3 "" H 4950 2900 50  0001 C CNN
+F 2 "Package_QFP:TQFP-44_10x10mm_P0.8mm" H 4950 2900 50  0001 C CNN
+F 3 "http://ww1.microchip.com/downloads/en/DeviceDoc/Atmel-7766-8-bit-AVR-ATmega16U4-32U4_Datasheet.pdf" H 4950 2900 50  0001 C CNN
 	1    4950 2900
 	1    0    0    -1
 $EndComp
-$Comp
-L Bertha_main-eagle-import:M02JST-PTH-2 JP?
-U 1 1 5EE193A9
-P 5050 4425
-F 0 "JP?" H 4922 4422 59  0000 R CNN
-F 1 "M02JST-PTH-2" H 4922 4527 59  0000 R CNN
-F 2 "" H 5050 4425 50  0001 C CNN
-F 3 "" H 5050 4425 50  0001 C CNN
-	1    5050 4425
-	1    0    0    1
-$EndComp
-$Comp
-L Bertha_main-eagle-import:M02JST-PTH-2 JP?
-U 1 1 5EE199A8
-P 5050 4750
-F 0 "JP?" H 4922 4747 59  0000 R CNN
-F 1 "M02JST-PTH-2" H 4922 4852 59  0000 R CNN
-F 2 "" H 5050 4750 50  0001 C CNN
-F 3 "" H 5050 4750 50  0001 C CNN
-	1    5050 4750
-	1    0    0    1
-$EndComp
-Text GLabel 5500 4850 2    50   Input ~ 0
-GND
-Wire Wire Line
-	5500 4425 5350 4425
-Wire Wire Line
-	5350 4525 5500 4525
-Wire Wire Line
-	5500 4750 5350 4750
-Wire Wire Line
-	5500 4850 5350 4850
 $EndSCHEMATC

Commit message: change power supply for LCD1602
Parts:
- C13, C14, C15, C16, C17, C18: footprint (none) -> Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
- J7: footprint (none) -> Jumper:SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
- JP5: footprint (none) -> Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical
- R29, R30, R31: footprint (none) -> Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
- X2: footprint (none) -> Crystal:Crystal_SMD_0603-2Pin_6.0x3.5mm_HandSoldering
Changed lines of the file:
@@
 F 0 "R31" V 6325 1900 50  0000 C CNN
 F 1 "10k" V 6400 1900 50  0000 C CNN
-F 2 "" V 6330 1900 50  0001 C CNN
+F 2 "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" V 6330 1900 50  0001 C CNN
 F 3 "~" H 6400 1900 50  0001 C CNN
 	1    6400 1900
@@
 F 0 "C16" H 3490 4496 50  0000 L CNN
 F 1 "100nF" H 3490 4405 50  0000 L CNN
-F 2 "" H 3413 4300 50  0001 C CNN
+F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 3413 4300 50  0001 C CNN
 F 3 "~" H 3375 4450 50  0001 C CNN
 	1    3375 4450
@@
 F 0 "R30" V 3925 3025 50  0000 L CNN
 F 1 "1M" V 3825 3100 50  0000 L CNN
-F 2 "" V 3755 3150 50  0001 C CNN
+F 2 "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" V 3755 3150 50  0001 C CNN
 F 3 "~" H 3825 3150 50  0001 C CNN
 	1    3825 3150
@@
 F 0 "X2" V 3775 3250 50  0000 R CNN
 F 1 "XTALNX6035" V 3225 3375 50  0000 R CNN
-F 2 "" H 3525 3150 50  0001 C CNN
+F 2 "Crystal:Crystal_SMD_0603-2Pin_6.0x3.5mm_HandSoldering" H 3525 3150 50  0001 C CNN
 F 3 "" H 3525 3150 50  0001 C CNN
 	1    3525 3150
@@
 F 0 "C13" V 2925 3050 50  0000 C CNN
 F 1 "22pF" V 3000 3050 50  0000 C CNN
-F 2 "" H 3163 2900 50  0001 C CNN
+F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 3163 2900 50  0001 C CNN
 F 3 "~" H 3125 3050 50  0001 C CNN
 	1    3125 3050
@@
 F 0 "C14" V 3325 3250 50  0000 C CNN
 F 1 "22pF" V 3250 3275 50  0000 C CNN
-F 2 "" H 3163 3100 50  0001 C CNN
+F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 3163 3100 50  0001 C CNN
 F 3 "~" H 3125 3250 50  0001 C CNN
 	1    3125 3250
@@
 F 0 "C18" V 3575 2775 50  0000 C CNN
 F 1 "100nF" V 3675 2775 50  0000 C CNN
-F 2 "" H 3663 2450 50  0001 C CNN
+F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 3663 2450 50  0001 C CNN
 F 3 "~" H 3625 2600 50  0001 C CNN
 	1    3625 2600
@@
 F 0 "C17" V 3825 2000 50  0000 C CNN
 F 1 "100nF" V 3750 2000 50  0000 C CNN
-F 2 "" H 3663 1850 50  0001 C CNN
+F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 3663 1850 50  0001 C CNN
 F 3 "~" H 3625 2000 50  0001 C CNN
 	1    3625 2000
@@
 F 0 "R29" V 3175 875 50  0000 L CNN
 F 1 "10k" V 3075 925 50  0000 L CNN
-F 2 "" V 3005 1000 50  0001 C CNN
+F 2 "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" V 3005 1000 50  0001 C CNN
 F 3 "~" H 3075 1000 50  0001 C CNN
 	1    3075 1000
@@
 F 0 "J7" V 3000 1050 59  0000 L CNN
 F 1 "SJ" V 3125 1175 59  0000 L CNN
-F 2 "" H 3075 1350 50  0001 C CNN
+F 2 "Jumper:SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm" H 3075 1350 50  0001 C CNN
 F 3 "" H 3075 1350 50  0001 C CNN
 	1    3075 1350
@@
 F 0 "C15" H 3150 1275 50  0000 C CNN
 F 1 "100nF" H 3175 1450 50  0000 C CNN
-F 2 "" H 3338 1200 50  0001 C CNN
+F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 3338 1200 50  0001 C CNN
 F 3 "~" H 3300 1350 50  0001 C CNN
 	1    3300 1350
@@
 F 0 "JP5" H 4947 4397 59  0000 R CNN
 F 1 "M02JST-PTH-2" H 4947 4502 59  0000 R CNN
-F 2 "" H 5075 4400 50  0001 C CNN
+F 2 "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" H 5075 4400 50  0001 C CNN
 F 3 "" H 5075 4400 50  0001 C CNN
 	1    5075 4400
