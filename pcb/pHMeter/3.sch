File: pcb/pHMeter/3.sch (KiCad schematic (older format))
At the start: 12 parts

Commit message: update 3.sch in pHmeter PCB to change ACT4088 for AP62303 (3.3 V compatible)
Parts:
- added C?: 10u, symbol Device:C
- added C?: 100n, symbol Device:C
- added C? (x2): 22u, symbol Device:C
- added L?: 3.9u, symbol Device:L
- added U?: AP63203WU-7, Package_TO_SOT_SMD:TSOT-23-6, symbol bioreactor:AP63203WU-7
Connections:
- net 3.3V: now also C?.2, C?.2, L?.2, U?.1 (FB)
- net GND: now also C?.1, C?.1, C?.2, U?.4 (GND)
- net VIN: now also C?.1, U?.2 (EN), U?.3 (IN)
- new net: C?.1, L?.1, U?.5 (SW)
- new net: C?.2, U?.6 (BST)
Other:
- note added: "The inductor’s DC resistance should be less than 100mΩ.\n \nThe input capacitor, electrolytic, or ceramics with low ESR should be used."
Changed lines of the file:
@@
 $EndComp
 NoConn ~ 2525 2150
+$Comp
+L Device:C C?
+U 1 1 5EDC3622
+P 3650 6000
+F 0 "C?" H 3765 6046 50  0000 L CNN
+F 1 "10u" H 3765 5955 50  0000 L CNN
+F 2 "" H 3688 5850 50  0001 C CNN
+F 3 "~" H 3650 6000 50  0001 C CNN
+	1    3650 6000
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	3950 6000 3900 6000
+Wire Wire Line
+	3900 6000 3900 5800
+Wire Wire Line
+	3900 5800 3950 5800
+Wire Wire Line
+	3900 5800 3650 5800
+Wire Wire Line
+	3650 5800 3650 5850
+Connection ~ 3900 5800
+Wire Wire Line
+	3650 5800 3600 5800
+Connection ~ 3650 5800
+Wire Wire Line
+	3650 6225 3650 6150
+Wire Wire Line
+	4350 6200 4350 6275
+Text HLabel 3600 5800 0    50   Input ~ 0
+VIN
+Text HLabel 3650 6225 0    50   Input ~ 0
+GND
+Text HLabel 4350 6275 0    50   Input ~ 0
+GND
+$Comp
+L Device:C C?
+U 1 1 5EDCC8A2
+P 4975 5900
+F 0 "C?" V 4723 5900 50  0000 C CNN
+F 1 "100n" V 4814 5900 50  0000 C CNN
+F 2 "" H 5013 5750 50  0001 C CNN
+F 3 "~" H 4975 5900 50  0001 C CNN
+	1    4975 5900
+	0    1    1    0
+$EndComp
+Wire Wire Line
+	4750 5900 4825 5900
+Wire Wire Line
+	5125 5900 5200 5900
+Wire Wire Line
+	5200 5900 5200 5800
+Wire Wire Line
+	5200 5800 4750 5800
+$Comp
+L Device:L L?
+U 1 1 5EDCF040
+P 5400 5800
+F 0 "L?" V 5590 5800 50  0000 C CNN
+F 1 "3.9u" V 5499 5800 50  0000 C CNN
+F 2 "" H 5400 5800 50  0001 C CNN
+F 3 "~" H 5400 5800 50  0001 C CNN
+	1    5400 5800
+	0    -1   -1   0
+$EndComp
+Wire Wire Line
+	5250 5800 5200 5800
+Connection ~ 5200 5800
+Wire Wire Line
+	5550 5800 5600 5800
+Wire Wire Line
+	5600 5800 5600 6000
+Wire Wire Line
+	5600 6000 4750 6000
+$Comp
+L Device:C C?
+U 1 1 5EDD102F
+P 5725 6000
+F 0 "C?" H 5610 5954 50  0000 R CNN
+F 1 "22u" H 5610 6045 50  0000 R CNN
+F 2 "" H 5763 5850 50  0001 C CNN
+F 3 "~" H 5725 6000 50  0001 C CNN
+	1    5725 6000
+	-1   0    0    1
+$EndComp
+Wire Wire Line
+	5725 5850 5725 5800
+Wire Wire Line
+	5725 5800 5600 5800
+Connection ~ 5600 5800
+Wire Wire Line
+	5725 6150 5725 6225
+Text HLabel 5725 6225 0    50   Input ~ 0
+GND
+Text HLabel 6200 5800 2    50   Output ~ 0
+3.3V
+Wire Wire Line
+	6200 5800 6075 5800
+Connection ~ 5725 5800
+$Comp
+L Device:C C?
+U 1 1 5EDE0CF8
+P 6075 6000
+F 0 "C?" H 5960 5954 50  0000 R CNN
+F 1 "22u" H 5960 6045 50  0000 R CNN
+F 2 "" H 6113 5850 50  0001 C CNN
+F 3 "~" H 6075 6000 50  0001 C CNN
+	1    6075 6000
+	-1   0    0    1
+$EndComp
+Wire Wire Line
+	6075 5850 6075 5800
+Connection ~ 6075 5800
+Wire Wire Line
+	6075 5800 5725 5800
+Text HLabel 6075 6225 0    50   Input ~ 0
+GND
+Wire Wire Line
+	6075 6150 6075 6225
+Text Notes 3425 6575 0    50   ~ 0
+The inductor’s DC resistance should be less than 100mΩ.\n \nThe  input  capacitor,  electrolytic,  or  ceramics  with  low  ESR  should  be  used.
+$Comp
+L bioreactor:AP63203WU-7 U?
+U 1 1 5EDBF789
+P 4350 5900
+F 0 "U?" H 4350 6267 50  0000 C CNN
+F 1 "AP63203WU-7" H 4350 6176 50  0000 C CNN
+F 2 "Package_TO_SOT_SMD:TSOT-23-6" H 4350 5000 50  0001 C CNN
+F 3 "https://www.diodes.com/assets/Datasheets/AP65111A.pdf" H 4350 5900 50  0001 C CNN
+	1    4350 5900
+	1    0    0    -1
+$EndComp
 $EndSCHEMATC

Commit message: Add LCD1602, I2C and Alk/Acid Foods into pHmeter
Parts:
- gave numbers to parts that had none: 16
- renumbered R22 to R34, R23 to R35
Changed lines of the file:
@@
 $EndDescr
 $Comp
-L ACT4088:ACT4088 U?
+L ACT4088:ACT4088 U4
 U 1 1 5E004CC9
 P 4325 4000
-F 0 "U?" H 4325 4715 50  0000 C CNN
+F 0 "U4" H 4325 4715 50  0000 C CNN
 F 1 "ACT4088" H 4325 4624 50  0000 C CNN
 F 2 "Package_TO_SOT_SMD:SOT-23-6_Handsoldering" H 4375 4000 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:C C?
+L Device:C C21
 U 1 1 5E004CCF
 P 4775 3750
-F 0 "C?" H 4890 3796 50  0000 L CNN
+F 0 "C21" H 4890 3796 50  0000 L CNN
 F 1 "22nF" H 4890 3705 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 4813 3600 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:R R?
+L Device:R R33
 U 1 1 5E004CDB
 P 5125 4350
-F 0 "R?" V 5225 4400 50  0000 C CNN
+F 0 "R33" V 5225 4400 50  0000 C CNN
 F 1 "49.9k" V 5025 4400 50  0000 C CNN
 F 2 "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" V 5055 4350 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:R R?
+L Device:R R32
 U 1 1 5E004CE1
 P 4775 4600
-F 0 "R?" H 4705 4554 50  0000 R CNN
+F 0 "R32" H 4705 4554 50  0000 R CNN
 F 1 "16.23k" H 4705 4645 50  0000 R CNN
 F 2 "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" V 4705 4600 50  0001 C CNN
@@
 Connection ~ 5575 3950
 $Comp
-L Device:C C?
+L Device:C C20
 U 1 1 5E004D0F
 P 3775 3900
-F 0 "C?" H 3890 3946 50  0000 L CNN
+F 0 "C20" H 3890 3946 50  0000 L CNN
 F 1 "10µF" H 3890 3855 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 3813 3750 50  0001 C CNN
@@
 	5575 3950 6175 3950
 $Comp
-L Device:D D?
+L Device:D D7
 U 1 1 5E004D28
 P 4775 4100
-F 0 "D?" V 4729 4179 50  0000 L CNN
+F 0 "D7" V 4729 4179 50  0000 L CNN
 F 1 "B240A" V 4820 4179 50  0000 L CNN
 F 2 "Diode_SMD:D_SOD-123" H 4775 4100 50  0001 C CNN
@@
 AR Path="/5E0D7D04/5E1D0FCF" Ref="R?"  Part="1"
 AR Path="/5E1D0FCF" Ref="R?"  Part="1"
-AR Path="/5E0005EE/5E1D0FCF" Ref="R22"  Part="1"
-AR Path="/5ED0DFF6/5E1D0FCF" Ref="R?"  Part="1"
-F 0 "R?" V 8250 3625 50  0000 C CNN
+AR Path="/5E0005EE/5E1D0FCF" Ref="R?"  Part="1"
+AR Path="/5ED0DFF6/5E1D0FCF" Ref="R34"  Part="1"
+F 0 "R34" V 8250 3625 50  0000 C CNN
 F 1 "10k" V 8325 3625 50  0000 C CNN
 F 2 "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" V 8255 3625 50  0001 C CNN
@@
 AR Path="/5E0D7D04/5E1D0FDF" Ref="R?"  Part="1"
 AR Path="/5E1D0FDF" Ref="R?"  Part="1"
-AR Path="/5E0005EE/5E1D0FDF" Ref="R23"  Part="1"
-AR Path="/5ED0DFF6/5E1D0FDF" Ref="R?"  Part="1"
-F 0 "R?" V 8250 4225 50  0000 C CNN
+AR Path="/5E0005EE/5E1D0FDF" Ref="R?"  Part="1"
+AR Path="/5ED0DFF6/5E1D0FDF" Ref="R35"  Part="1"
+F 0 "R35" V 8250 4225 50  0000 C CNN
 F 1 "1k" V 8325 4225 50  0000 C CNN
 F 2 "Resistor_SMD:R_0805_2012Metric_Pad1.15x1.40mm_HandSolder" V 8255 4225 50  0001 C CNN
@@
 GND
 $Comp
-L Device:C C?
+L Device:C C23
 U 1 1 5E004CFD
 P 5575 4150
-F 0 "C?" H 5690 4196 50  0000 L CNN
+F 0 "C23" H 5690 4196 50  0000 L CNN
 F 1 "22µF" H 5690 4105 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 5613 4000 50  0001 C CNN
@@
 	1    0    0    -1
 $EndComp
-Text HLabel 3475 5000 0    79   Input ~ 0
+Text HLabel 3475 5000 0    50   Input ~ 0
 GND
 Wire Wire Line
@@
 	4775 4750 4775 5000
 Connection ~ 4325 5000
-Text HLabel 4775 4250 0    51   Input ~ 0
-GND
-Text HLabel 6925 3900 0    79   Input ~ 0
+Text HLabel 4775 4250 0    50   Input ~ 0
+GND
+Text HLabel 6925 3900 0    50   Input ~ 0
 GND
 Wire Wire Line
@@
 	6950 3900 6950 4225
 Connection ~ 6950 3900
-Text HLabel 8550 3625 2    51   Input ~ 0
+Text HLabel 8550 3625 2    50   Input ~ 0
 VIN
-Text HLabel 8550 4225 2    51   Input ~ 0
+Text HLabel 8550 4225 2    50   Input ~ 0
 3.3V
-Text HLabel 5575 4500 2    51   Input ~ 0
+Text HLabel 5575 4500 2    50   Input ~ 0
 GND
 Wire Wire Line
@@
 Connection ~ 3775 3700
 $Comp
-L Device:LED D?
+L Device:LED D8
 U 1 1 5E883301
 P 7425 3625
-F 0 "D?" H 7425 3550 50  0000 C CNN
+F 0 "D8" H 7425 3550 50  0000 C CNN
 F 1 "RED" H 7425 3725 50  0000 C CNN
 F 2 "LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 7425 3625 50  0001 C CNN
@@
 $EndComp
 $Comp
-L Device:LED D?
+L Device:LED D9
 U 1 1 5E886D2D
 P 7425 4225
-F 0 "D?" H 7425 4150 50  0000 C CNN
+F 0 "D9" H 7425 4150 50  0000 C CNN
 F 1 "RED" H 7425 4325 50  0000 C CNN
 F 2 "LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 7425 4225 50  0001 C CNN
@@
 3.3V LDO
 $Comp
-L Device:L L?
+L Device:L L1
 U 1 1 5E004CD5
 P 5125 3950
-F 0 "L?" V 5200 3950 50  0000 C CNN
+F 0 "L1" V 5200 3950 50  0000 C CNN
 F 1 "4.7µH" V 5075 3950 50  0000 C CNN
 F 2 "Inductor_SMD:L_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 5125 3950 50  0001 C CNN
@@
 NoConn ~ 2525 2150
 $Comp
-L Device:C C?
+L Device:C C19
 U 1 1 5EDC3622
 P 3650 6000
-F 0 "C?" H 3765 6046 50  0000 L CNN
+F 0 "C19" H 3765 6046 50  0000 L CNN
 F 1 "10u" H 3765 5955 50  0000 L CNN
 F 2 "" H 3688 5850 50  0001 C CNN
@@
 GND
 $Comp
-L Device:C C?
+L Device:C C22
 U 1 1 5EDCC8A2
 P 4975 5900
-F 0 "C?" V 4723 5900 50  0000 C CNN
+F 0 "C22" V 4723 5900 50  0000 C CNN
 F 1 "100n" V 4814 5900 50  0000 C CNN
 F 2 "" H 5013 5750 50  0001 C CNN
@@
 	5200 5800 4750 5800
 $Comp
-L Device:L L?
+L Device:L L2
 U 1 1 5EDCF040
 P 5400 5800
-F 0 "L?" V 5590 5800 50  0000 C CNN
+F 0 "L2" V 5590 5800 50  0000 C CNN
 F 1 "3.9u" V 5499 5800 50  0000 C CNN
 F 2 "" H 5400 5800 50  0001 C CNN
@@
 	5600 6000 4750 6000
 $Comp
-L Device:C C?
+L Device:C C24
 U 1 1 5EDD102F
 P 5725 6000
-F 0 "C?" H 5610 5954 50  0000 R CNN
+F 0 "C24" H 5610 5954 50  0000 R CNN
 F 1 "22u" H 5610 6045 50  0000 R CNN
 F 2 "" H 5763 5850 50  0001 C CNN
@@
 Connection ~ 5725 5800
 $Comp
-L Device:C C?
+L Device:C C25
 U 1 1 5EDE0CF8
 P 6075 6000
-F 0 "C?" H 5960 5954 50  0000 R CNN
+F 0 "C25" H 5960 5954 50  0000 R CNN
 F 1 "22u" H 5960 6045 50  0000 R CNN
 F 2 "" H 6113 5850 50  0001 C CNN
@@
 The inductor’s DC resistance should be less than 100mΩ.\n \nThe  input  capacitor,  electrolytic,  or  ceramics  with  low  ESR  should  be  used.
 $Comp
-L bioreactor:AP63203WU-7 U?
+L bioreactor:AP63203WU-7 U5
 U 1 1 5EDBF789
 P 4350 5900
-F 0 "U?" H 4350 6267 50  0000 C CNN
+F 0 "U5" H 4350 6267 50  0000 C CNN
 F 1 "AP63203WU-7" H 4350 6176 50  0000 C CNN
 F 2 "Package_TO_SOT_SMD:TSOT-23-6" H 4350 5000 50  0001 C CNN

Commit message: change power supply for LCD1602
Parts:
- C19, C22, C24, C25: footprint (none) -> Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
- L2: footprint (none) -> Inductor_SMD:L_TDK_SLF6028
Changed lines of the file:
@@
 F 0 "C19" H 3765 6046 50  0000 L CNN
 F 1 "10u" H 3765 5955 50  0000 L CNN
-F 2 "" H 3688 5850 50  0001 C CNN
+F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 3688 5850 50  0001 C CNN
 F 3 "~" H 3650 6000 50  0001 C CNN
 	1    3650 6000
@@
 F 0 "C22" V 4723 5900 50  0000 C CNN
 F 1 "100n" V 4814 5900 50  0000 C CNN
-F 2 "" H 5013 5750 50  0001 C CNN
+F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 5013 5750 50  0001 C CNN
 F 3 "~" H 4975 5900 50  0001 C CNN
 	1    4975 5900
@@
 F 0 "L2" V 5590 5800 50  0000 C CNN
 F 1 "3.9u" V 5499 5800 50  0000 C CNN
-F 2 "" H 5400 5800 50  0001 C CNN
+F 2 "Inductor_SMD:L_TDK_SLF6028" H 5400 5800 50  0001 C CNN
 F 3 "~" H 5400 5800 50  0001 C CNN
 	1    5400 5800
@@
 F 0 "C24" H 5610 5954 50  0000 R CNN
 F 1 "22u" H 5610 6045 50  0000 R CNN
-F 2 "" H 5763 5850 50  0001 C CNN
+F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 5763 5850 50  0001 C CNN
 F 3 "~" H 5725 6000 50  0001 C CNN
 	1    5725 6000
@@
 F 0 "C25" H 5960 5954 50  0000 R CNN
 F 1 "22u" H 5960 6045 50  0000 R CNN
-F 2 "" H 6113 5850 50  0001 C CNN
+F 2 "Capacitor_SMD:C_0805_2012Metric_Pad1.15x1.40mm_HandSolder" H 6113 5850 50  0001 C CNN
 F 3 "~" H 6075 6000 50  0001 C CNN
 	1    6075 6000
